# Keil uVision project Zeta.uvprojx, settings and files
target NBI_Zeta (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Zeta_Farm_V02 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_MODEM_LORA,USE_BAND_433,USING_RS485
  c misc: --C99
  c include: ..\CMSIS\Device\ST\STM32L0xx\Include;..\CMSIS\Include;..\stm32L0xx_HAL\Inc\Legacy;..\stm32L0xx_HAL\Inc;..\USER;..\HAL\sensor\inc;..\HAL\system;..\HAL\inc;..\Lib\LoRawan-node\misc;..\Lib\LoRawan-node\radio;..\Lib\LoRawan-node\radio\sx1276;..\Lib\LoRawan-node\mac;..\Lib\LoRawan-node\crypto;..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l073xx.s
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group stm32L0xx_HAL
    ../stm32L0xx_HAL/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group HAL\src
    ../HAL/src/: usart.c rtc-board.c delay.c gpio-board.c adc.c dma.c power.c led.c wwdg.c timer-board.c spi.c user_spi_flash.c
  group HAL\system
    ../HAL/system/: board.c stmflash.c
  group HAL\sensor\src
    ../HAL/sensor/src/: rs485.c sensor.c gps.c FIFO_Uart.c
  group USER
    ../USER/: main.c stm32l0xx_it.c user-app.c Zeta.c
  group DOC
    ../DOC/: readme.txt
